Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA250L_INT-EN.ifc
Time: 2025-08-05T18:34:51+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2172676_1
Port_2172676_2

# IfcValve: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN:HA250L, M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN:HA250L:2172676
In: F00
Type - Material: Color RAL 1003, Color RGB 128-128-128, Color RGB 198-000-000, Color RGB 168-128-048
Type - Other - Category: Pipe Accessories; Body Radius: 254 mm; Diameter: 508 mm; Dist A: 136.5 mm; Dist B: 3 mm; Dist C: 23 mm; Dist D: 132.9 mm; Drain Visibility: yes; End: no; End Distance: 74 mm; Family Name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN; Geometry Radius: 101.6 mm; Handle Offset: 408 mm; Radius A: 202.5 mm; Radius B: 160 mm; Rings: yes; Rings Distance: 268 mm; Rings Height: 356 mm; Rings Offset: 30 mm; Ring Visibility: yes; Valve Distance: 1516 mm; With Flanges: no
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Nominal Diameter: 250 mm; Connection Outer Diameter: 273 mm; H: 1806 mm; h1: 441 mm; L: 750 mm; LF: 890 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator - Steel- Weld DN250 - High Flow; Article Type: HA250L; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator - Steel- Weld DN250 - High Flow; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; Manufacturer: Spirotech; Manufacturer Art. No.: HA250L; Manufacturer URL: https://www.spirotech.com/products/spirovent/; MEPcontent Class: SEPARATOR_AIR; Model: HA250L; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: HA250L; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Air Vent: Color RGB 168-128-048; Drain Body: Color RGB 128-128-128; Drain Handle: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0.32111 m3/s; K Coefficient: 0
Type - Mechanical - Flow - Kv: 0.32111 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: HA250L; sets with these values: 2
Other - Connection Diameter: 250 mm; Connector Offset: 375 mm; Connector Offset Total: 750 mm; Family: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN; Family and Type: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN: HA250L; Type: HA250L; Type Id: 2172629
Constraints - Elevation from Level: 0 mm
Dimensions - Maximum Size: 250 mm; Minimum Size: 250 mm; Volume: 0.338535 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
