Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 6f0957dd-03e5-4dcf-9efe-4b98d1b06f86, NumberOfSaves: 0]
File name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA300L_INT-EN.ifc
Time: 2025-08-26T15:06:30+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENU) - IFC 23.4.0.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_103141_1
Port_103141_2

# IfcValve: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN:HA300L, M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN:HA300L:103141
In: Level 1
Type - Material: Color RAL 1003, Color RGB 128-128-128, Color RGB 198-000-000, Color RGB 168-128-048
Type - Other - Category: Pipe Accessories; Body Radius: 305 mm; Diameter: 610 mm; Dist A: 161.9 mm; Dist B: 4 mm; Dist C: 24 mm; Dist D: 158.3 mm; Drain Visibility: yes; End: no; End Distance: 74 mm; Family Name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN; Geometry Radius: 122 mm; Handle Offset: 408 mm; Radius A: 230 mm; Radius B: 189 mm; Rings: yes; Rings Distance: 320 mm; Rings Height: 491 mm; Rings Offset: 18 mm; Ring Visibility: yes; Valve Distance: 1796 mm; With Flanges: no
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Nominal Diameter: 0.00328084 mm; Connection Outer Diameter: 323.8 mm; H: 2118 mm; h1: 503 mm; L: 850 mm; LF: 1005 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator - Steel- Weld DN300 - High Flow; Article Type: HA300L; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator - Steel- Weld DN300 - High Flow; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; Manufacturer: Spirotech; Manufacturer Art. No.: HA300L; Manufacturer URL: https://www.spirotech.com/products/spirovent/; MEPcontent Class: SEPARATOR_AIR; Model: HA300L; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: HA300L; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Air Vent: Color RGB 168-128-048; Drain Body: Color RGB 128-128-128; Drain Handle: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 427.78 dm3/s; K Coefficient: 0
Type - Mechanical - Flow - Kv: 427.78 dm3/s
Type - Text - Pipe Type Category: M561
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: HA300L; sets with these values: 2
Other - Connection Diameter: 0.00328084 mm; Connector Offset: 425 mm; Connector Offset Total: 850 mm; Family: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN; Family and Type: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN: HA300L; Type: HA300L; Type Id: 103126
Constraints - Elevation from Level: 0 mm
Dimensions - Maximum Size: 0.00328084 mm; Minimum Size: 0.00328084 mm; Volume: 0.576847 m3
Identity Data - Mark: 1
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 dm3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
