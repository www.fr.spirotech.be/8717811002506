Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA150L_INT-EN.ifc
Time: 2025-08-05T18:34:56+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2172680_1
Port_2172680_2

# IfcValve: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN:HA150L, M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN:HA150L:2172680
In: F00
Type - Material: Color RGB 128-128-128, Color RGB 198-000-000, Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Body Radius: 162 mm; Diameter: 324 mm; Dist A: 84.15 mm; Dist B: 3 mm; Dist C: 19 mm; Dist D: 80.55 mm; Drain Visibility: yes; End: no; End Distance: 74 mm; Family Name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN; Geometry Radius: 64.8 mm; Handle Offset: 300 mm; Radius A: 129 mm; Radius B: 106 mm; Rings: no; Rings Distance: 320 mm; Rings Height: 436 mm; Rings Offset: 43 mm; Ring Visibility: yes; Valve Distance: 873 mm; With Flanges: no
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Nominal Diameter: 150 mm; Connection Outer Diameter: 168.3 mm; H: 1094 mm; h1: 272 mm; L: 525 mm; LF: 635 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator - Steel- Weld DN150 - High Flow; Article Type: HA150L; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator - Steel- Weld DN150 - High Flow; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; GTIN: 8717811002551; Manufacturer: Spirotech; Manufacturer Art. No.: HA150L; Manufacturer URL: https://www.spirotech.com/8717811002551; MEPcontent Class: SEPARATOR_AIR; Model: HA150L; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: HA150L; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Air Vent: Color RGB 168-128-048; Drain Body: Color RGB 128-128-128; Drain Handle: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0.14389 m3/s; K Coefficient: 0
Type - Mechanical - Flow - Kv: 0.14389 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: HA150L; sets with these values: 2
Other - Connection Diameter: 150 mm; Connector Offset: 262.5 mm; Connector Offset Total: 525 mm; Family: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN; Family and Type: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_HA_INT-EN: HA150L; Type: HA150L; Type Id: 2172637
Constraints - Elevation from Level: 0 mm
Dimensions - Maximum Size: 150 mm; Minimum Size: 150 mm; Volume: 0.0786414 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
